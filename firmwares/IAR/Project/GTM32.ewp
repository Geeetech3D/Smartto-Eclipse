# IAR project GTM32.ewp, settings and files
configuration A30 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: WS2811; BOARD_A30_MINI_S
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\STM32F10x_Core; ..\STM32F10x_Start_up; ..\STM32F10x_StdPeriph_Driver\inc; ..\STM32f10x_USB_FS_Device_Driver\inc; ..\User; $TOOLKIT_DIR$\..\arm\CMSIS\Include; ..\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A30_APP_S_V1.bin
  ILINK.IlinkOutputFile: GTM32.out
  ILINK.IlinkIcfFile: stm32f10x_flash_s200.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration E180 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: WS2811; BOARD_E180_MINI_S
  OBJCOPY.OOCOutputFile: E180_APP_S_V1.bin
configuration A30M (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: WS2811; BOARD_A30M_Pro_S
  OBJCOPY.OOCOutputFile: E180_APP_S_V1.bin
configuration A30D (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: WS2811; BOARD_A30D_Pro_S
  OBJCOPY.OOCOutputFile: A30D_APP_S_V1.bin
configuration M301 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: WS2811
  OBJCOPY.OOCOutputFile: E180_APP_S_V1.bin
  group STM32F10x_Core
    ../STM32F10x_Core/: core_cm3.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
    ../STM32F10x_Start_up/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: adc.c adc.h ccsbcs.c char_table.h Command.c command.h Configuration_GTM32_Pro_A30S.h data_handle.c data_handle.h delay.c delay.h Dgus_screen.c Dgus_screen.h diskio.c diskio.h endstop.c endstop.h fat.c fat.h fat_config.h gta.c integer.h LCD2004.c LCD2004.h main.c MMC_SD.C mmc_sd.h planner.c planner.h qr_solve.c qr_solve.h recovery_print.c recovery_print.h rocker.c rocker.h rxfile.c rxfile.h sd.c sd.h sd_print.c serial_print.c setting.c setting.h spi.c spi.h step_motor.c step_motor.h stm32f10x.h stm32f10x_it.c stm32f10x_it.h stmflash.c stmflash.h temperature_table.h UI_table.h usart1.c usart1.h variable.c variable.h vector_3.c vector_3.h wifi.c XZK_Configuration.h XZK_Rule.h
