<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Machine_GiantArm_S200</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Machine_Delta</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Machine_M201</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Machine_GiantArm_D200</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>STM32F10x_Core</name>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_Core\core_cm3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_Start_up\startup_stm32f10x_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_Core\stm32f10x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_Core\stm32f10x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_Core\system_stm32f10x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_Core\system_stm32f10x.h</name>
    </file>
  </group>
  <group>
    <name>STM32F10x_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\User\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\ccsbcs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\char_table.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Command.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\command.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\data_handle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\data_handle.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Dgus_screen.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\Dgus_screen.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\diskio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\diskio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\endstop.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\endstop.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\fat.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\fat.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\fat_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\gta.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\integer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\LCD2004.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\LCD2004.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\MMC_SD.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\mmc_sd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\planner.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\planner.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\qr_solve.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\qr_solve.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\recovery_print.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\recovery_print.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\rocker.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\rocker.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\rxfile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\rxfile.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\sd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\sd_print.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\serial_print.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\setting.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\setting.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\step_motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\step_motor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm32f10x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm32f10x_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stmflash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stmflash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\temperature_table.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\UI_table.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\usart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\usart1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\variable.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\variable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\vector_3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\vector_3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\wifi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\XZK_Configuration.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\XZK_Rule.h</name>
    </file>
  </group>
</project>


